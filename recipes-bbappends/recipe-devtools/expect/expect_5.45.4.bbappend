EXTRA_OECONF:append = " --with-tcl=${STAGING_LIBDIR}/tcl8.6"

